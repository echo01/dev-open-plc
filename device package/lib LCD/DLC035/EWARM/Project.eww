<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32H563ZI_NUCLEO_AZ2.ewp</path>
  </project>
  <batchBuild />
</workspace>
